File: TOLT-DC48V-3KW-TOBO2-SinglePhase/EVAL_TOLT_DC48V_3KW.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Commit 1
Other:
- removed sheet V-Phase
- removed sheet W-Phase
