File: EVAL-TOLT-DC-48V-3KW-TOBO2-1206/EVAL_TOLT_DC48V_3KW.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Oct17
Other:
- removed sheet V-Phase
- removed sheet W-Phase
